Commit message: CACTO-refactoring V3

File: urdf/double_integrator.urdf (robot description, URDF)
Before this commit: robot planar_manipulator_3dof, 4 links, 3 joints
Links:
- link EE: mass 0.5 -> 1
